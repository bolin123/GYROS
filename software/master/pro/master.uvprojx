# Keil uVision project master.uvprojx, settings and files
target master (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\hal;..\app;..\lib\inc;..\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: APP.c main.c SysButton.c
  group hal
    ../hal/: HalCommon.c HalGPIO.c HalSpi.c HalTimer.c HalUart.c HalWait.c CC1101.c HalFlash.c
  group lib
    ../lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c
  group sys
    ../sys/: Sys.c SysCommand.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
