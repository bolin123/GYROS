# Keil uVision project atcmd.uvprojx, settings and files
target atcmd (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atcmd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\lib\inc;..\app;..\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../lib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_dma.c
  group app
    ../app/: app.c main.c
  group hal
    ../hal/: HalCommon.c HalGPIO.c HalUart.c HalTimer.c HalWait.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
